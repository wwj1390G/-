# Keil uVision project STM32F4.uvprojx, settings and files
target ICAPTURE (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,USE_USB_OTG_FS
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE;..\APP;..\IMU;..\IMU\HardwareDriver;..\USMART;..\PID;..\RC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/: led.c my_math.c PWM.c Time2.c flash.c Time_system.c GALV.c moter_controller.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_wwdg.c stm32f4xx_flash.c
  group IMU
    ../IMU/: filter.c IMU.C IMU_hand.c calm_acc.c calm_gyro.c calm_mag.c
    ../IMU/HardwareDriver/: IIC_imit.c MPU6000.c MS5611.c QMC5883L.c SPI_MPU.c
  group APP
    ../APP/: uart_app.c APP_ANO.c
  group RC
    ../RC/: cppm.c uart_dma.c RC_data.c
  group PID
    ../PID/: PID.c PID_controller.c
